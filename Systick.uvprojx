# Keil uVision project Systick.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: EEPROM_I2C +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Start;.\User;.\Lib;.\Hardware\KEY;.\Hardware\LED;.\Hardware\Usart;.\Hardware\I2C;.\Hardware\EEPROM;.\Hardware\DELAY;.\Hardware\Systick
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Start
    ./Start/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h startup_stm32f10x_hd.s
  group User
    ./User/: main.c
  group Hardware/led
    ./Hardware/LED/: LED.c
  group Hardware/key
    ./Hardware/KEY/: key.c
  group HardWare/delay
    ./Hardware/DELAY/: delay.c
  group HardWare/Usart
    ./Hardware/Usart/: Usart.c
  group HardWare/I2C
    ./Hardware/I2C/: I2C.c
  group HardWare/Eeprom
    ./Hardware/EEPROM/: EEPROM.c
  group Systick
    ./Hardware/Systick/: systick.c
